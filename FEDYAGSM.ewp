# IAR project FEDYAGSM.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m8 ATmega8
  ICCAVR.CCDefines: _SYSTEM_BUILD; FRMWRI_BUFSIZE=32; QSORT_MAXSIZE=32; SCANF_MAXLINE=32
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: _SYSTEM_BUILD; FRMWRI_BUFSIZE=32; QSORT_MAXSIZE=32; SCANF_MAXLINE=32; NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group Compiler support
    $EW_DIR$/avr/src/lib/: _exit.s90 debug.s90 eeprom.s90 l01.s90 l02.s90 l03.s90 l04.s90 l05.s90 l06.s90 l07.s90 l08.s90 l09.s90 l10.s90 l11.s90 l12.s90 low_level_init.c macros.m90 segment_init.c segment_init.h
